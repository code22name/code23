options:
  parameters:
    author: vib-dragon
    generate_options: qt_gui
    id: vk2
    output_language: python
    title: vk2
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/vib-dragon/Documents/dataout.bin
    type: float
    unbuffered: 'True'
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5002
    timeout: '100'
    type: float
  states: {}

connections:
- [zeromq_sub_source_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
