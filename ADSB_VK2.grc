options:
  parameters:
    author: VIbhore Kumar
    generate_options: qt_gui
    id: VK3
    output_language: python
    title: ADS-B
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: ADSB_VK_0
  id: ADSB_VK
  parameters:
    comment: adsb decoder developed by vibhore kumar
    samp_rate: samp_rate
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0.0010'
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    comment: convert complex data into float
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: gsm_message_file_sink_0
  id: gsm_message_file_sink
  parameters:
    filename: /home/vib-dragon/Documents/outmsg.msg
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,1,1,1
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 1024*10
    gui_hint: 1,2,1,1
    int_max: '50'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    dc_offset_mode0: '2'
    freq0: 1090e6
    gain0: '45'
    gain_mode0: 'True'
    if_gain0: '30'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:5001
    timeout: '100'
  states: {}
- name: zeromq_pub_msg_sink_0_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:5002
    timeout: '100'
  states: {state: disabled}

connections:
- [ADSB_VK_0, '0', qtgui_time_sink_x_0, '0']
- [ADSB_VK_0, '1', blocks_null_sink_0_0, '0']
- [ADSB_VK_0, ADSB Demodulated Output, gsm_message_file_sink_0, in]
- [ADSB_VK_0, Decoded Data, zeromq_pub_msg_sink_0, in]
- [ADSB_VK_0, Decoded Data, zeromq_pub_msg_sink_0_0, in]
- [analog_const_source_x_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_mag_squared_0, '0', ADSB_VK_0, '0']
- [blocks_complex_to_real_0, '0', ADSB_VK_0, '0']
- [rtlsdr_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [rtlsdr_source_0, '0', blocks_complex_to_real_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
